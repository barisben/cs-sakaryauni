ORG 0000H
SJMP ANA
ORG 0030H
ANA:
MOV P1,#01H
ACALL GECIKME

MOV P1,#02H
ACALL GECIKME

MOV P1,#04H
ACALL GECIKME

MOV P1,#08H
ACALL GECIKME

MOV P1,#10H
ACALL GECIKME

MOV P1,#20H
ACALL GECIKME

MOV P1,#40H
ACALL GECIKME

MOV P1,#80H
ACALL GECIKME

SJMP ANA

GECIKME:
mov r6,#00h
tkrr:
mov r7,#00h
djnz r7,$
djnz r6,tkrr
ret
end