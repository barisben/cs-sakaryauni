	ORG 0H
	SJMP START
	ORG 30H
START:
	MOV P1,#0FFH
	MOV P2,#0
LOOP:
	JB P1.0,RELEASE
	SETB P2.0
	ACALL DELAY
	CLR P2.0
	SETB P2.1
	ACALL DELAY
	CLR P2.1
	SJMP LOOP
DELAY:
	MOV R0,#20
BACK:
	MOV TMOD,#01H
	MOV TH0,#03CH
	MOV TL0,#0B0H
	SETB TR0
CONTROL:
	JB P1.0,RELEASE
	JNB TF0,CONTROL
	CLR TR0
	CLR TF0
	DJNZ R0,BACK
	RET
RELEASE:
	MOV P2,#0
	SJMP LOOP
	END